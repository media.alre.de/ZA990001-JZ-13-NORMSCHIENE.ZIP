Properties of the parts of a building model (IFC2X3)

# File
Description: Normschiene zur Befestigung von Schaltschrankreglern, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: ZA990001, Normschiene zur Befestigung von Schaltschrankreglern
In: Raum
Description: Normschiene mit Bohrlöchern zur Befestigung von Schaltschrankreglern, Länge 40 mm; Classification: EC001285 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: ZA990001; ModelLabel: JZ-13; GlobalTradeItemNumber: 4050528064301; ProductURL: https://alre.de/produkt_ZA990001
Pset_Specification - NominalLength: 0.04 m; NominalWidth: 0.035 m; NominalDepth: 0.0075 m; NetWeight: 0.015
Pset_ALRE_ETIM_Properties - Höhe: 40; Oberflächenschutz: unbehandelt; Länge: 35; Lochform: Rundloch; Werkstoff: Stahl; ETIM-Klasse: EC001285; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-ZA990001.pdf
